# IAR project servo_app.ewp, settings and files
configuration stm32h743vit6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743VI ST STM32H743VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32H743xx; RAM_DEBUG=0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\Driver\Inc; ..\..\CMSIS\Inc; ..\..\Bsp\LED; ..\..\Bsp\SPI; ..\..\Bsp\UART; ..\..\STM32H7xx_Device\Inc; ..\..\App; ..\..\Bsp\Delay; ..\..\Bsp\It_Handler; ..\..\Bsp\I2C; ..\..\Lib; ..\..\Bsp\STS40
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: servo_app.bin
  ILINK.IlinkOutputFile: servo_app.elf
  ILINK.IlinkIcfFile: servo_app_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: startup_stm32h743xx.s
  group App
    ../../App/: main.c boot_jump.c gsa200_uart5.c waveform_uart7.c
  group Bsp
    ../../Bsp/LED/: bsp_led.c
    ../../Bsp/UART/: bsp_uart.c
    ../../Bsp/: system_stm32h7xx.c
  group Driver
    ../../Driver/Src/: stm32h7xx_ll_dma.c stm32h7xx_ll_gpio.c stm32h7xx_ll_i2c.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_spi.c stm32h7xx_ll_usart.c stm32h7xx_ll_utils.c
